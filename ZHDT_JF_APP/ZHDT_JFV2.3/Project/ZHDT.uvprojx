# Keil uVision project ZHDT.uvprojx, settings and files
target ZHDT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZHDT +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin --Output ../Output/test_ZS.bin ../obj/ZHDT.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User\main;..\User\delay;..\User\LOOP;..\User\usart2;..\User\spi;..\User\MQTT;..\User\spi;..\User\Tim2;..\User\socket;..\User\IWDG;..\User\gpio;..\User\w5500;..\User\DHT11;..\User\dhcp;..\User\usart3;..\User\usart1;..\User\24c16;..\User\ADXL345;..\User\adc;..\User\exti;..\User\BDTG;..\User\MQTTBDTG;..\User\TCPDEMO
  library: MicroLIB
  memory RVCT4: ROM 0x8005000 size 0x7afff
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group USER
    ../User/main/: main.c stm32f10x_it.c
    ../User/IWDG/: iwdg.c
    ../User/usart2/: usart2.c
    ../User/Tim2/: Tim2.c
    ../User/delay/: delay.c
    ../User/spi/: spi2.c
    ../User/gpio/: gpio.c
    ../User/24c16/: 24c16.c
    ../User/usart3/: usart3.c
    ../User/usart1/: usart1.c
    ../User/ADXL345/: ADXL345.c
    ../User/adc/: adc.c
    ../User/exti/: exti.c
  group LOOP
    ../User/LOOP/: LOOP.c
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group w5500
    ../User/w5500/: w5500.c w5500_config.c
    ../User/socket/: socket.c
  group DHT11
    ../User/DHT11/: dht11.c
  group dhcp
    ../User/dhcp/: dhcp.c ult.c
  group MQTT
    ../User/MQTTBDTG/: MqttKit.c
  group BDTG
    ../User/BDTG/: BD_TG.c
  group TCP
    ../User/TCPDEMO/: tcp_demo.c
